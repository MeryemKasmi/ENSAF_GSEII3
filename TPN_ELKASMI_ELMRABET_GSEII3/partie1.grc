options:
  parameters:
    generate_options: qt_gui
    id: partie1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: script1.length_stream(path)
  states: {}
- name: NFFT
  id: variable
  parameters:
    value: script1.nextpow2(N)
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
    widget: dial
  states: {}
- name: path
  id: variable
  parameters:
    value: '''/home/wijdane/audio_1.wav'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: b
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: NFFT
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/wijdane/audio_2.wav
    type: float
    vlen: NFFT
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: NFFT
    type: float
  states: {}
- name: blocks_vector_insert_x_0
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: N
    type: float
    vector: np.zeros(NFFT-N)
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: path
    repeat: 'False'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: NFFT
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(NFFT)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: script1
  id: epy_module
  parameters:
    source_code: "import numpy as np\r\n\r\ndef length_stream(Path='/home/wijdane/audio_1.wav'):\r\n\treturn len(np.fromfile(Path))\r\n        \r\ndef nextpow2(N):\r\n\tn=0\r\n\twhile 2**n <N :\r\n\t\tn=n+1\t\r\n\treturn 2**n\r\n        \r\n"
  states: {}

connections:
- [b, '0', blocks_vector_insert_x_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_insert_x_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_wavfile_source_0, '0', b, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
